# Keil uVision project Blinky.uvprojx, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Flash OPT
    ./: STM32F40xxx_41xxx_OPT.s
  group Source Files
    ./: fputc_def.c main.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Boards/ST/STM32F4-Discovery/Common/: Keyboard.c LED.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/RTE_Driver/: GPIO_STM32F4xx.c
target STM32F407 Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.20.0, Board Support:STM32F4-Discovery:Keyboard 1.0.0, Board Support:STM32F4-Discovery:LED 1.0.0, Device:GPIO 1.0.0, Device:Startup 1.3.0
